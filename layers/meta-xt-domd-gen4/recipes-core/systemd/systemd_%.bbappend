SRC_URI:remove:r8a779g0 = "file://add-non-owned-item-for-safe-transitioning.patch"
